options:
  parameters:
    author: jholtom
    generate_options: qt_gui
    id: julia_mult_test
    output_language: python
    title: Julia Multiplication Test
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '10'
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '3'
    freq: '0.01'
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: float
    waveform: analog.GR_COS_WAVE
  states: {}
- name: analog_sig_source_x_0_0
  id: analog_sig_source_x
  parameters:
    amp: '3'
    freq: '1000'
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: float
    waveform: analog.GR_CONST_WAVE
  states: {}
- name: bindjulia_cppmult_0
  id: bindjulia_cppmult
  parameters: {}
  states: {}
- name: bindjulia_pyjulia_mult_0
  id: bindjulia_pyjulia_mult
  parameters: {}
  states: {state: disabled}
- name: blocks_null_sink_0
  id: blocks_null_sink
  parameters:
    type: float
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    size: '1024'
    srate: samp_rate
    tr_mode: qtgui.TRIG_MODE_AUTO
    type: float
  states: {}

connections:
- [analog_sig_source_x_0, '0', bindjulia_cppmult_0, '0']
- [analog_sig_source_x_0, '0', bindjulia_pyjulia_mult_0, '0']
- [analog_sig_source_x_0_0, '0', bindjulia_cppmult_0, '1']
- [analog_sig_source_x_0_0, '0', bindjulia_pyjulia_mult_0, '1']
- [bindjulia_cppmult_0, '0', blocks_null_sink_0, '0']
- [bindjulia_cppmult_0, '0', qtgui_time_sink_x_0, '0']
- [bindjulia_pyjulia_mult_0, '0', blocks_null_sink_0, '0']
- [bindjulia_pyjulia_mult_0, '0', qtgui_time_sink_x_0, '0']

metadata:
  file_format: 1
